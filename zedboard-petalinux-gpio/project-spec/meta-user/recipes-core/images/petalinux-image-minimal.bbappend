IMAGE_INSTALL_append = " gpio-demo"